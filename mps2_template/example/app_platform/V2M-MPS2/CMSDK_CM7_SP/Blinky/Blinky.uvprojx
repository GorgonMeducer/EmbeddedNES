# Keil uVision project Blinky.uvprojx, settings and files
target Simulator (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.4.0-RC6
  cpu: IROM(0x00000000,0x400000) IRAM(0x20000000,0x400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: __USE_TIMER0 __USE_FPGA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group Source Files
    ./: Blinky.c stdout_USART.c
  group Documentation
    ./: Abstract.txt
target FastModels (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.4.0-RC6
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target V2M-MPS2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.4.0-RC6
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target V2M-MPS2 Trace (ETB) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.4.0-RC6
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA __DBG_ITM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target V2M-MPS2 Trace (TPIU) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.4.0-RC6
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA __DBG_ITM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
software components: CMSIS:CORE 5.0.0, Board Support:Buttons 2.0.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:USART 1.0, Compiler:I/O:STDOUT 1.1.0, Compiler:I/O:STDOUT 1.1.0, Device:Startup 1.0.0
