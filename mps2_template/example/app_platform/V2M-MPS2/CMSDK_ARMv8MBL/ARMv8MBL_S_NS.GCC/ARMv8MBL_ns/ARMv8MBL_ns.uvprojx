# Keil uVision project ARMv8MBL_ns.uvprojx, settings and files
target V2M-MPS2 (6040000::V6.4::.\ARMCLANG)
  device: CMSDK_ARMv8MBL ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.5.0-dev3
  cpu: IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) IRAM(0x20000000,0x00200000) IRAM2(0x20200000,0x00200000) CPUTYPE("ARMv8MBL") CLOCK(12000000) ELITTLE
  output: ARMv8MBL_ns
  group Source Group 1
    ./: main_ns.c
  group CMSE Library
    ../ARMv8MBL_s/Objects/: ARMv8MBL_s_CMSE_Lib.o
    ../ARMv8MBL_s/: Secure_Functions.h
  group Documentation
    ../: Abstract.txt
target Fast Model (6040000::V6.4::.\ARMCLANG)
  device: CMSDK_ARMv8MBL ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.5.0-dev3
  cpu: as above
  output: ARMv8MBL_ns
software components: CMSIS:CORE 5.0.0, Board Support:Common 2.0.0, Board Support:LED 2.0.0, Device:Startup 1.0.0
