# Keil uVision project Blinky.uvprojx, settings and files
target V2M-MPS2-LiteNES (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: msp2_file_io_template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=1
  c define: __USE_LCD __USE_TIMER0 __USE_FPGA USE_LITE_NES __USER_DEFINED_APP_CFG_H__ GLCD_MIRROR_Y=0
  c misc: --wchar32  --loop_optimization_level=2 --no_unaligned_access
  c include: ..\..\LiteNES;..\..\LiteNES\src\fce;..\..\LiteNES\include;..\..\app_platform
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
  group Source Files
    ../../../sources/gmsi/utilities/arm/: signal.c
    ../../LiteNES/src/: hal.c
    ../../: system.c app_cfg.h
  group Documentation
    ./: Abstract.txt
    ../../../../: README.md
  group gmsi
    ../../../sources/gmsi/: gmsi.c
    ../../../sources/gmsi/hal/bsp/: bsp.c
    ../../../sources/gmsi/hal/: hal.c
    ../../../sources/gmsi/hal/component/: component.c
    ../../../sources/gmsi/hal/component/bootloader/: bootloader.c
    ../../../sources/gmsi/hal/component/key/: key.c
    ../../../sources/gmsi/hal/component/key/key_queue/: key_queue.c
    ../../../sources/gmsi/hal/component/memory/mal/: mal.c
    ../../../sources/gmsi/hal/component/memory/mal/sdf_w25qxxx/: sdf_w25qxxx.c
    ../../../sources/gmsi/hal/component/memory/mal/sram/: sram.c
    ../../../sources/gmsi/hal/component/memory/page/: page.c
    ../../../sources/gmsi/hal/component/sw_sdio/: sw_sdio.c
    ../../../sources/gmsi/service/communication/crc/: crc.c crc7.c crc8.c crc16.c crc32.c
    ../../../sources/gmsi/service/communication/frame/es_simple_frame/: es_simple_frame.c
    ../../../sources/gmsi/service/communication/xmodem/: xmodem.c
    ../../../sources/gmsi/service/encryption/random/: random.c
    ../../../sources/gmsi/service/memory/: memory.c
    ../../../sources/gmsi/service/memory/epool/: epool.c
    ../../../sources/gmsi/service/scheduler/: scheduler.c shell.c task.c
    ../../../sources/gmsi/service/: service.c
    ../../../sources/gmsi/service/memory/stream2block/: stream2block.c stream2block.h
    ../../../sources/: environment_cfg.h app_cfg.h
    ../../../sources/gmsi/utilities/template/: t_list.c t_list.h t_pool.h t_queue.h template.h
    ../../../sources/gmsi/service/communication/telegraph_engine/: telegraph_engine.c telegraph_engine.h
    ../../../sources/gmsi/service/time/: time.c time.h
    ../../../sources/gmsi/service/time/multiple_delay/: multiple_delay.c multiple_delay.h
    ../../../sources/gmsi/service/memory/block_queue/: block_queue.c block_queue.h
    ../../../sources/gmsi/service/memory/block/: block.c block.h
    ../../../: README.md
    ../../../sources/gmsi/utilities/: delegate.c
  group app_platform
    ../../app_platform/: file_io.h app_platform.h app_platform.c stdout_USART.c stdout_USART.h generic_io_lib_armv6-m_size.lib generic_io_lib_armv6-m_speed.lib generic_io_lib_armv7-m_size.lib generic_io_lib_armv7-m_speed.lib generic_io_stream.lib bsp.h
  group LiteNES
    ../../LiteNES/src/fce/: common.c cpu.c cpu-addressing.c fce.c memory.c mmc.c ppu.c psg.c cartridge.c cartridge.h ppu_new.c ppu_new.h
  group jeg
    ../../jeg/: cartridge.c cpu6502.c cpu6502_opcodes.c nes.c ui.c fce.h hal.h fce.c cpu6502.h cpu6502_debug.h cpu6502_opcodes.h jeg_cfg.h ppu_pixel_based.c ppu.c common.h
  group rom
    ../../LiteNES/roms/: Super_Tank.s Road Fighter.s Super_Mario_Bros.s Contra.s
  group BSP-STM32F746G-Discovery
    ../../app_platform/STM32F746G-Discovery/: app_cfg.h bsp.c bsp.h
  group BSP-V2M-MPS2
    ../../app_platform/V2M-MPS2/Common/: GLCD_Fonts.c GLCD_V2M-MPS2.c
    ../../app_platform/V2M-MPS2/: app_cfg.h bsp.c bsp.h
target V2M-MPS2-jeg (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: msp2_file_io_template +hex
  c flags: oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: __USE_COMPILER_SPECIFIED_CMSIS_PATH__ _MSC_VER __USE_LCD  USE_JEG  __USER_DEFINED_APP_CFG_H__ GLCD_MIRROR_Y=1 JEG_USE_EXTERNAL_DRAW_PIXEL_INTERFACE=ENABLED JEG_USE_FRAME_SYNC_UP_FLAG=ENABLED JEG_MAX_ALLOWED_SPRITES_ON_SINGLE_SCANLINE=32 JEG_USE_EXTRA_16BIT_BUS_ACCESS=ENABLED JEG_USE_DMA_MEMORY_COPY_ACCELERATION=ENABLED
  c misc: -Omax -fms-extensions -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ..\..\app_platform;..\..\jeg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target STM32F746-Discovery-Lib (6130000::V6.13::.\ARMCompiler6.13)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: msp2_file_io_template +hex
  c flags: oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: __USE_COMPILER_SPECIFIED_CMSIS_PATH__ __USE_STM32F746G_DISCOVERY__ _MSC_VER USE_JEG  __USER_DEFINED_APP_CFG_H__ GLCD_MIRROR_Y=1 JEG_USE_EXTERNAL_DRAW_PIXEL_INTERFACE=ENABLED JEG_USE_FRAME_SYNC_UP_FLAG=ENABLED JEG_MAX_ALLOWED_SPRITES_ON_SINGLE_SCANLINE=32 JEG_USE_EXTRA_16BIT_BUS_ACCESS=ENABLED JEG_USE_DMA_MEMORY_COPY_ACCELERATION=ENABLED
  c misc: as above
  c include: ..\..\app_platform;..\..\jeg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\STM32F746G_Discovery.sct
target rom_lib (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: nes_rom_lib +hex (library)
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _MSC_VER __USE_LCD  USE_JEG  __USER_DEFINED_APP_CFG_H__ GLCD_MIRROR_Y=1 JEG_USE_EXTERNAL_DRAW_PIXEL_INTERFACE=ENABLED JEG_USE_FRAME_SYNC_UP_FLAG=ENABLED JEG_MAX_ALLOWED_SPRITES_ON_SINGLE_SCANLINE=32 JEG_USE_EXTRA_16BIT_BUS_ACCESS=ENABLED JEG_USE_DMA_MEMORY_COPY_ACCELERATION=ENABLED
  c misc: -fms-extensions -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ..\..\app_platform;..\..\jeg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Buttons 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Graphic LCD 1.1.1, Board Support:LED 1.1.1, Board Support:Buttons 2.0.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:USART 1.0.3, CMSIS Driver:USART 1.13.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:LTDC 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:SDRAM 1.2.7, Device:STM32Cube HAL:UART 1.2.7, Device:STM32Cube HAL:USART 1.2.7, Device:Startup 1.0.0, Device:Startup 1.2.4
